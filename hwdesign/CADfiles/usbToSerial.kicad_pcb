# Repository etimou/usbToSerial

## KiCad design hwdesign/CADfiles/usbToSerial.kicad_pcb

Parts:
C1: 0.1u
C2, C3: 27p
D1, D2: 3.3
IC1: ATMEGA328-P; DIL28
J1: USB_A_MALE
P1: CONN_6
R1: 10k
R2, R3: 470
R4, R5: 68
R6: 1.5k
X1: CRYSTAL

Connections:
/CTS: P1.5, R1.2
/DTR: IC1.26 ((PCINT11/ADC3)PC3), P1.1
/RTS: IC1.27 ((PCINT12/SDA/ADC4)PC4)
/RXD: P1.3, R3.2
/TXD: P1.2, R2.2
GND: C1.2, C2.2, C3.2, D1.1 (A), D2.1 (A), IC1.8 (GND), IC1.22 (GND), J1.4, P1.6
unnamed: IC1.4 ((PCINT18/INT0)PD2), R4.1
unnamed: D2.2 (K), J1.2, R5.2, R6.1
unnamed: D1.2 (K), J1.3, R4.2
unnamed: IC1.28 ((PCINT14/SCL/ADC5)PC5), R1.1
unnamed: IC1.3 ((PCINT17/TXD)PD1), R3.1
unnamed: IC1.2 ((PCINT16/RXD)PD0), R2.1
unnamed: C2.1, IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), X1.2
unnamed: IC1.5 ((PCINT19/OC2B/INT1)PD3), R5.1
unnamed: C3.1, IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), X1.1
VCC: C1.1, IC1.7 (VCC), IC1.20 (AVCC), J1.1, P1.4, R6.2

Board: 2 copper layers, 100.0 x 48.0 mm, 17 parts (0 on the bottom side), 15 nets.

Other parts of the board:
1PIN, 1PIN#2: P***; A_1pin

## Commit log

2013-11-15 first commit with unmodifed sourcecode
2013-11-15 code mofication to be compatible with arduino programming (auto reset)
